# Keil uVision project Project.uvprojx, settings and files
target gps_logger (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: stml0_gps_logger
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L053xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER
  c misc: --C99
  c include: ../sys;../STM32Cube_FW_L0_V1.7.0/Drivers/CMSIS/Device/ST/STM32L0xx/Include;../STM32Cube_FW_L0_V1.7.0/Drivers/STM32L0xx_HAL_Driver/Inc;../STM32Cube_FW_L0_V1.7.0/Drivers/BSP/STM32L0xx_Nucleo;../app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L053R8_NUCLEO
    ../STM32Cube_FW_L0_V1.7.0/Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/STM32L0xx_HAL_Driver
    ../STM32Cube_FW_L0_V1.7.0/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_pwr.c stm32l0xx_hal_uart.c stm32l0xx_hal_flash.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_rcc.c
  group Drivers/CMSIS
    ../sys/: system_stm32l0xx.c
  group app
    ../app/: main.c main.h
  group sys
    ../sys/: startup_stm32l053xx.s stm32l0xx_hal_msp.c stm32l0xx_it.c stm32l0xx_hal_conf.h stm32l0xx_it.h
  group docs
    ../docs/: todo.txt
software components: CMSIS:CORE 4.3.0
